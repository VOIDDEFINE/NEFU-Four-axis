# Keil uVision project NEFU_Four_Axis.uvproj, settings and files
target NEFU_Four_Axis (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: NEFU_Four_Axis
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\BSP\Control;..\BSP\Delay;..\BSP\IIC;..\BSP\Inv_mpu;..\BSP\Inv_mpu_dmp_motion_driver;..\BSP\MPU6050;..\BSP\Sys;..\BSP\Timer;..\BSP\Uart_for_Dbus;..\BSP\Uart_for_Pc;..\BSP\APP;..\BSP\Uart_for_Hc_sr04;..\BSP\MYIIC;..\BSP\Motor
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ./: system_stm32f10x.c
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_can.c
  group SYSTEM
    ./: main.c stm32f10x_it.c
  group BSP
    ../BSP/Timer/: timer.c
    ../BSP/Delay/: delay.c
    ../BSP/MYIIC/: myiic.c
    ../BSP/MPU6050/: mpu6050.c
    ../BSP/Inv_mpu/: inv_mpu.c
    ../BSP/Inv_mpu_dmp_motion_driver/: inv_mpu_dmp_motion_driver.c
    ../BSP/Uart_for_Dbus/: Uart_for_Dbus.c
    ../BSP/Uart_for_Pc/: Uart_for_Pc.c
    ../BSP/Uart_for_Hc_sr04/: Uart_for_Hc_sr04.c
    ../BSP/Motor/: motor.c
  group APP
    ../BSP/Control/: control.c
    ../BSP/APP/: app.c
